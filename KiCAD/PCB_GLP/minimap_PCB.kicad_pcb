# Repository ymkn/minimap

File README.md:

# minimap

キーボード設計プロジェクト。KiCad設計、FreeCAD設計、文書、画像、ファームウェアの案内を分離した。現行Choc版とMX/GLP3版を保持し、過去版・試行履歴は `archive/` に保管する。

## 編集対象

| 対象 | 開くファイル | 保存されている設計 |
| --- | --- | --- |
| Choc V2 PCB・回路図 | `KiCAD/PCB/minimap_PCB.kicad_pro` | 114.5mm角、裏面ナット四点固定 |
| Choc V2プレート | `KiCAD/SwitchPlate/minimap_ChocV2Plate.kicad_pro` | 114.5mm角、14.0mm・R0.5の35開口、厚さ1.2mm、市松・ロゴ・minimap文字 |
| 本体ケース・奥端ウェイト | `FreeCAD/minimap.FCStd` | 外寸120.5mm角、110×14mmウェイト、5°、金属／3DP代替Body |
| 額縁ケース検討案 | `FreeCAD/concepts/picture-frame/minimap_frame.FCStd` | 外寸130.5mm角、三段の額縁・46本の目盛り溝。現行ケースとは別の外観検討用 |
| MX/GLP3 PCB・回路図 | `KiCAD/PCB_GLP/minimap_PCB.kicad_pro` | 126.25×114.5mm、旧ダンパー取付構造 |
| GLP3プレート | `KiCAD/SwitchPlate_GLP/minimap_SwitchPlate.kicad_pro` | 126.25×114.5mm、14.1mm・R0.5の35開口、厚さ1.2mm |

MX/GLP3とChocでは外形・固定方式が異なる。**現在のケースをMX/GLP3用として扱わない。** `minimap.FCStd` には本体ケースの `Case` Bodyと、代替ウェイトの `WeightMetal`・`WeightPrint` Bodyが含まれる。ウェイトだけのCADではない。

「現行」は今回残す設計版を意味し、製造承認ではない。全版 `production_ready=false`。実物の安定性・強度・公差・実金具・スイッチ着座高さ・全実装部品・加工適合は未認定。検討用STEPを本番製造・加工発注へ使わない。今回、新たなDRC・CAD再計算・Gerber生成は行っていない。

## ディレクトリ

```text
minimap/
├─ KiCAD/
│  ├─ PCB/                  # Choc V2
│  ├─ PCB_GLP/              # MX/GLP3
│  ├─ SwitchPlate/          # Choc V2プレート
│  ├─ SwitchPlate_GLP/      # GLP3プレート
│  └─ lib/external/         # ymknlibs・非フリーロゴ
├─ FreeCAD/
│  ├─ minimap.FCStd         # 現行の本体ケース・ウェイト
│  ├─ STEP/                 # 現行CADに対応する3点
│  └─ concepts/
│     └─ picture-frame/     # 額縁検討案のCAD・STEP・画像・検査記録
├─ doc/                     # 恒久的な設計説明・input/KLS
├─ image/                   # 公開・説明用の恒久的な画像
├─ firmware/               # WSL側ファームウェアの所在案内
└─ archive/                # 過去版・試行履歴（Git対象外）
```

PCBの詳細は [doc/pcb.md](doc/pcb.md)、プレートは [doc/plates.md](doc/plates.md)、ケースは [doc/case.md](doc/case.md)。設計元のKLSは `doc/input/minimap.kls.json`（レイアウトは維持し、名称のみ更新）。過去の検査・作業報告と一時レビュー画像は `archive/doc/reports/`・`archive/image/` に保管し、`doc/`・`image/` には置かない。

`archive/` は `.gitignore` の `/archive/` で除外する。削除はしていないが、**Gitで取得・復元される対象にはならないため、保管が必要なら別途バックアップする。**

作業履歴は `archive/` に保管する。過去のスクリプト・JSON・CAD内のSourceFile等に残る旧パスは履歴として保持しており、旧スクリプトをそのまま再実行しない。

外観検討案は `FreeCAD/concepts/` 内で案ごとにまとめ、CAD・対応STEP・説明画像・既存検査記録を同じディレクトリに置く。現行設計の出力や恒久画像とは混在させない。詳細は [額縁検討案のREADME](FreeCAD/concepts/picture-frame/README.md) を参照。自動バックアップ・一時ファイルはGit対象外とし、残す必要のある控えは `archive/` に退避する。

## 依存ライブラリと出典

- `KiCAD/lib/external/ymknlibs`：submodule、固定commit `db12e941510b766ef9056fc83638b4f0245368ad`。SWD三穴・暫定M2ナット・公称モデル・出典通知を含む。ライブラリの修正用リポジトリは `../ymknlibs`。
- `KiCAD/lib/external/ymknlibs-nonfree`：submodule、固定commit `4cd0a35976a805284cbc0c04509bade35a44c603`。非フリーのロゴを含むため同梱の `LICENSE` に従う。
- SWDとナットは `ymknlib_Various` に共通化。ナット名の `PROVISIONAL` は維持し、実装工程適合・はんだ接合強度は未承認。出典はライブラリの `licenses/NOTICE-SMTSO2010CTJ.md`。
- 外部ライブラリは `.gitmodules` とsubmoduleのcommitで版を固定し、自動更新しない。標準ライブラリはKiCad 10の環境変数を利用し、既存の `${KICAD8_3RD_PARTY}` 参照も残る。
- ライブラリ・モデル・ロゴ等は、それぞれに同梱されたライセンス・通知に従う。

取得先は `https://github.com/ymkn/minimap.git`。

```sh
git clone --recurse-submodules https://github.com/ymkn/minimap.git
```

通常のclone後は `git submodule update --init --recursive` でライブラリを取得する。ライブラリを更新して共有するときは、ライブラリ側のcommitを先に公開し、そのcommitを参照するminimap側を後から公開する。非フリーライブラリの取得にはアクセス権が必要になる場合がある。

既存U3モデルの欠落と、検査環境で解決できないMXソケットの外部モデル参照は未修正。

## ファームウェア

所在と注意は [firmware/README.md](firmware/README.md)。本体はWSL2 Ubuntu側で管理し、今回コピー・移動していない。

## KiCad design KiCAD/PCB_GLP/minimap_PCB.kicad_pcb

File KiCAD/README.md:

# KiCad設計

各基板・プレートを独立したプロジェクトディレクトリに置く。

| ディレクトリ | 対象 |
| --- | --- |
| `PCB/` | 現行114.5mm角Choc V2基板・回路図 |
| `PCB_GLP/` | 126.25×114.5mmのMX/GLP3基板・回路図 |
| `SwitchPlate/` | 現行114.5mm角Choc V2プレート |
| `SwitchPlate_GLP/` | 126.25×114.5mmのGLP3プレート |
| `lib/external/` | 共通のymknlibsと非フリーロゴのGit submodule |

設計の寸法・制約は [../doc/pcb.md](../doc/pcb.md) と [../doc/plates.md](../doc/plates.md)。SWD三穴と暫定M2ナットは `ymknlib_Various` に共通化し、旧プロジェクト専用ライブラリと未使用MCUはarchiveへ退避した。外部ライブラリはsubmoduleのcommitで版を固定し、自動更新しない。ライセンスは各ライブラリに同梱されたLICENSE・通知を参照。

**製造未承認。** この配置変更では新規DRC・Gerber生成を行っていない。

Parts:
C1, C4, C6: 100nF; C_0402_1005Metric; JLCPCB Part # C1525
C2, C3: 10uF; C_0603_1608Metric; JLCPCB Part # C19702
C5: 4.7uF; C_0402_1005Metric; JLCPCB Part # C23733
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35: 1N4148W; D_SOD-123; LCSC Parts # C81598
F1: SMD0603P020TF; Fuse_0603_1608Metric; JLCPCB Part # C20785
J1: TYPE-C 16PIN 2MD(073); USB_C_Receptacle_HRO_TYPE-C-31-M-12; JLCPCB Part # C2765186
J2: SWD_RPi_Debug_Probe; SWD_1x03_PlatedHoles_P2.54mm_D1.0mm; not fitted
R1, R2: 5.1K; R_0402_1005Metric; JLCPCB Part # C25905
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35: SW_Push; SW_MX_GLP3_1u; LCSC Parts # C5333465
U1: USBLC6-2SC6; SOT-23-6; JLCPCB Part # C7519
U2: XC6206P332MR; SOT-23-3; JLCPCB Part # C5446
U3: STM32G0B1CEU6; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm; JLCPCB Part # C2829190

Connections:
+3V3: C3.1, C5.1, C6.1, U2.2 (VO), U3.4 (VBAT), U3.6 (VDD)
COL0: SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, U3.44 (PB5)
COL1: SW6.1, SW7.1, SW8.1, SW9.1, SW10.1, SW11.1, U3.43 (PB4)
COL2: SW12.1, SW13.1, SW14.1, SW15.1, SW16.1, SW17.1, U3.42 (PB3)
COL3: SW18.1, SW19.1, SW20.1, SW21.1, SW22.1, SW23.1, U3.41 (PD3)
COL4: SW24.1, SW25.1, SW26.1, SW27.1, SW28.1, SW29.1, U3.39 (PD1)
COL5: SW30.1, SW31.1, SW32.1, SW33.1, SW34.1, SW35.1, U3.37 (PA15)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.2, R1.1, R2.2, U1.2 (GND), U2.1 (GND), U3.5 (VREF+), U3.7 (VSS), U3.49 (VSS)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R1.2
unnamed: C4.1, U3.10 (PF2)
ROW0: D6.1 (K), D12.1 (K), D18.1 (K), D24.1 (K), D30.1 (K), U3.16 (PA5)
ROW1: D1.1 (K), D7.1 (K), D13.1 (K), D19.1 (K), D25.1 (K), D31.1 (K), U3.17 (PA6)
ROW2: D2.1 (K), D8.1 (K), D14.1 (K), D20.1 (K), D26.1 (K), D32.1 (K), U3.18 (PA7)
ROW3: D3.1 (K), D9.1 (K), D15.1 (K), D21.1 (K), D27.1 (K), D33.1 (K), U3.19 (PB0)
ROW4: D4.1 (K), D10.1 (K), D16.1 (K), D22.1 (K), D28.1 (K), D34.1 (K), U3.20 (PB1)
ROW5: D5.1 (K), D11.1 (K), D17.1 (K), D23.1 (K), D29.1 (K), D35.1 (K), U3.21 (PB2)
SWCLK: J2.1, U3.36 (PA14)
SWDIO: J2.3, U3.35 (PA13)
USB_D+: J1.A6 (D+), J1.B6 (D+), U1.1 (I/O1), U1.6 (I/O1), U3.34 (PA10/PA12)
USB_D-: J1.A7 (D-), J1.B7 (D-), U1.3 (I/O2), U1.4 (I/O2), U3.33 (PA9/PA11)
USB_VBUS: C1.1, F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.5 (VBUS)
VBUS_FILT: C2.1, F1.2, U2.3 (VI)

Notes on the sheet:
MCU
SWD / Raspberry Pi Debug Probe
BOOT button removed. Keep PA13/PA14 in SWD mode.
1: SC (orange) 2: GND (black) 3: SD (yellow)
※USBコネクタ近傍
Keep PF2 as NRST. C4 = 100nF, close to pin 10.
3.3V I/O; power target from USB. No NRST / VTref pin.
※差動信号、配線長さ合わせる
ROW/COL GPIO assignment remains manual.
Key Matrix
V5: STM32G0B1CEU6 (GP, not CEU6N)
VBAT tied to 3V3. No external VDDIO2 supply pin.
USB / Power
VDD: 100nF + 4.7uF. VREF+: 100nF; VREFBUF disabled.

Board: 2 copper layers, 126.2 x 114.5 mm, 88 parts (84 on the bottom side), 58 nets.

Other parts of the board:
H_MOUNT1, H_MOUNT2, H_MOUNT3, H_MOUNT4: MountingHole_DampingBall_D3.2mm
